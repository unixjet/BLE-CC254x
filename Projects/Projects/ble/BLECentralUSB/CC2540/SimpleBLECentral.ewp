# IAR project SimpleBLECentral.ewp, settings and files
configuration CC2540EM (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=TRUE; HAL_LED=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\iSensorProfile; ..\App; ..\..\..\OnBoard\include
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2540USB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=TRUE; HAL_LED=TRUE; HAL_UART=TRUE; HAL_UART_USB=1; HAL_UART_BAUD_RATE=921600
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540USB; ..\..\..\..\Components\hal\target\CC2540USB\usb\library; ..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540; ..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb; ..\..\..\..\Components\hal\target\CC2540USB\usb\class_cdc; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\iSensorProfile; ..\App; ..\..\..\OnBoard\include
  group APP
    ../App/: BLECentralApp.c
    ../Source/: OSAL_simpleBLECentral.c simpleBLECentral_Main.c
  group APP/OnBoard
    ../../../Onboard/src/: OnBoardCenter.c putchar.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2540USB/Config
    ../../../../Components/hal/target/CC2540USB/: hal_board_cfg.h
  group HAL/Target/CC2540USB/Drivers
    ../../../../Components/hal/target/CC2540USB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540USB/include
    ../../../../Components/hal/target/CC2540USB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2540USB/USB/class_cdc
    ../../../../Components/hal/target/CC2540USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2540USB/USB/library
    ../../../../Components/hal/target/CC2540USB/usb/library/: usb_descriptor.h usb_framework.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2540USB/USB/library/cc2540
    ../../../../Components/hal/target/CC2540USB/usb/library/cc2540/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group HAL/Target/CC2540USB/USB/library/usb
    ../../../../Components/hal/target/CC2540USB/usb/library/usb/: usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework_structs.h usb_interrupt.h
  group LIB
    ../../../../../Libraries/CC2540DB/bin/: CC2540_BLE_cent.lib
    ../../../../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: central.c central.h gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
